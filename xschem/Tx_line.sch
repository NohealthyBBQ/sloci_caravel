v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 90 -200 190 -200 {}
N 90 -130 200 -130 {}
C {ipin.sym} 90 -200 0 0 {name=p1 lab=INA
}
C {opin.sym} 190 -200 0 0 {name=p2 lab=OUTA
}
C {ipin.sym} 90 -130 0 0 {name=p3 lab=INB
}
C {opin.sym} 190 -130 0 0 {name=p4 lab=OUTB}
